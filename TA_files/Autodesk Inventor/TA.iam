# Autodesk Inventor assembly: TA
## iProperties
Created: 2006-10
Part Number: TA
Document SubType Name: Assembly
Designer: Lab User
Author: Lab User
